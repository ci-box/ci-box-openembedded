FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-btf-Fix-building-with-system-libbpf.patch"

